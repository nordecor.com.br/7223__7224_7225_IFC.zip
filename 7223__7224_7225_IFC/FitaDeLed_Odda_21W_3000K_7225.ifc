Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-25T17:39:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 25 17:39:47 2024 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\e90ecbfb-8469-4a97-aafe-9f77ea980886\23c52eb2-b7c6-4293-8f53-41a4aec6d95d\ifc * Database version: 5507 * Database creation date: Fri Oct 25 17:39:47 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 25 17:39:47 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 25 17:39:47 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_329786
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 7225, FitaDeLed_Odda_21W_3000K_7225_IFC:7225:329786
In: Nível 1
Type - Classification: D5020200 Lighting Equipment (Uniformat); Material: LED, Plástico - Preto, Plástico - Branco
Type - Cotas - Largura da fita: 10 mm
Type - Dados - Data da atualização: 22/10/2024; Versão: 1
Type - Dados de identidade - Aplicação: Forro, madeira, perfil de alumínio; Código de montagem: D5020200; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Fita de LED 2835 ODDA 180LEDs/m 7.2W/m 3000K IP20 dimerizável 5m/rolo; Descrição de montagem: Lighting Equipment; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; Grau de proteção: IP20; Localização: Camboriú-SC / Brasil; Modelo: 7225; Nome do tipo: 7225; Número OmniClass: 23.80.70.11.11; Tipo de imagem: Imagem raster: Fitta ODDA.jpg; Título OmniClass: General Luminaries, Non Directional; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/fita-led-2835-odda-180leds-m-72w-m-2-700k-3-000k-4-000k/
Type - Elétrico - Comentários de voltagem: Recomendamos acessórios e fontes Nordecor para otimizar o desempenho e manter a garantia.; Lâmpada: 180 LEDs/m
Type - Elétrico - Cargas - Carga aparente - Fita de LED: 0 W; Fator de potência - Fita de LED: 1
Type - Engenharia elétrica - Voltagem - Fita de LED: 0 V
Type - Estrutural - Peso: 0.125
Type - Fotométricos - Eficácia luminosa: 755lm/m; Fluxo luminoso: 3775 lm; IRC: 97; Potência: 36 W; Temperatura de cor: 3000 K
Type - Gráficos - Simbologia: Imagem raster: 7225.png
Type - Materiais e acabamentos - Material: Cobre
Type - Outros - Categoria: Luminárias; Nome da família: FitaDeLed_Odda_21W_3000K_7225_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; Aviso: yes; Dimerizável: yes
Cotas - Altura da colocação: 0 mm; Área: 0.01101 m2; Comprimento: 1000 mm; Distância do aviso (acima): 10 mm; Distância do aviso (direita): 15 mm; Volume: 0.00001 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Array trechos: yes; Comprimento efetivo: 1000 mm; Comprimento mínimo: 18 mm; Família: FitaDeLed_Odda_21W_3000K_7225_IFC: 7225; Família e tipo: FitaDeLed_Odda_21W_3000K_7225_IFC: 7225; ID de tipo: FitaDeLed_Odda_21W_3000K_7225_IFC: 7225; n trechos: 56; Número trechos: 56; Peça única: no; Tipo: FitaDeLed_Odda_21W_3000K_7225_IFC: 7225
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
